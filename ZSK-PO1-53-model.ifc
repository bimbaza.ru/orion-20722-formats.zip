Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[DesignTransferView]
File name: /dev/null
Time: 2026-09-22T14:17:15+00:00
Written by: IfcOpenShell 0.8.5
Made in: IfcOpenShell 0.8.5
Authorization: Nobody

# IfcProject, ОРИОН ZSK-PO1-53
Classification: Классификатор строительных ресурсов (КСР)

# IfcFurnishingElement: Изделие бетонное благоустройства, ZSK-PO1-53 Столбик парковочный 530×700
In: Площадка
Description: Изделие бетонное благоустройства. Столбик парковочный 530×700; Classification: 59.1.15.01-0786 Стол (Классификатор строительных ресурсов (КСР)); Material: Бетон
Pset_ManufacturerTypeInformation - Manufacturer: Завод современных конструкций (ЗСК) · ООО «ПКФ «ОРИОН» · зск.рф · sales@zavod-orion.ru · 8 (351) 214-80-80; ModelLabel: ZSK-PO1-53; ModelReference: Столбик парковочный 530×700; ProductionYear: 2026; ArticleNumber: ZSK-PO1-53
ORION_Изделие - Артикул: ZSK-PO1-53; Артикул прежний: SD-PO1-53; Наименование: Столбик парковочный 530×700; Изготовитель: ООО «ПКФ «ОРИОН»; Марка: Завод современных конструкций (ЗСК); Город: Миасс, Челябинская область; Габариты: 530×530×700 мм; Материал: Бетон; Цена: 14 400 ₽; Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; Карточка изделия: https://зск.рф/catalog/concrete/20722; Код КСИ: CPr>EDD180; Класс КСИ: Стол; Коды КСР: 59.1.15.01-0786 … 59.1.15.01-1072
ADSK - ADSK_Наименование: Столбик парковочный 530×700; ADSK_Марка: ZSK-PO1-53; ADSK_Код изделия: 59.1.15.01-0786; ADSK_Завод-изготовитель: ООО «ПКФ «ОРИОН»; ADSK_Единица измерения: шт.; ADSK_Количество: 1; ADSK_Обозначение: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ADSK_Материал: Бетон; ADSK_URL страницы изделия: https://зск.рф/catalog/concrete/20722
ZSK_Благоустройство - ZSK_Нормативы: ГОСТ Р 52169-2012, ГОСТ Р 52301-2013; ZSK_Код_КСИ: CPr>EDD180; ZSK_Артикул_прежний: SD-PO1-53
Qto_ORION - Длина: 530 mm; Ширина: 530 mm; Высота: 700 mm
